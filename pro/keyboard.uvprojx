# Keil uVision project keyboard.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: keyboard +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ..\src\FWLIB\inc;..\src\Hal;..\src\System\Sys;..\src\User;..\src\CORE;..\src\M8266WIFI
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Hal
    ../src/Hal/: Hal.c HalGPIO.c HalTimer.c HalUart.c stm32f4xx_it.c system_stm32f4xx.c HalWait.c
  group Lib
    ../src/FWLIB/src/: misc.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_syscfg.c stm32f4xx_spi.c stm32f4xx_fsmc.c
  group Sys
    ../src/System/Sys/: System.c SysTimer.c
  group Usr
    ../src/User/: main.c PS2.c Demo.c MSocket.c Wifi.c
  group Core
    ../src/CORE/: startup_stm32f40_41xxx.s
  group Wifi
    ../src/M8266WIFI/: M8266HostIf_STM32xx.c M8266WIFI_ops.c M8266WIFIDrv_STM32F4xx.lib
